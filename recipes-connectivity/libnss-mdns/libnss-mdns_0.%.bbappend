DEPENDS = ""
RDEPENDS_${PN} = ""
