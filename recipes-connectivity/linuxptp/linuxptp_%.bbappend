PACKAGES =+ " phc2sys "
PROVIDES += " phc2sys "
DESCRIPTION_phc2sys = "PTP hardware clock synchronization utility"
FILES_phc2sys = "${bindir}/phc2sys"
