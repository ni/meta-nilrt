FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-interface.py-add-python3-compatibility-for-translate_to_dbus_type_function.patch"

