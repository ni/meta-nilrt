INITSCRIPT_PARAMS:avahi-daemon = "defaults 21 36"
INITSCRIPT_PARAMS:avahi-dnsconfd = "defaults 22 36"
