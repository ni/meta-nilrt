INITSCRIPT_PARAMS_avahi-daemon = "defaults 21 36"
INITSCRIPT_PARAMS_avahi-dnsconfd = "defaults 22 36"