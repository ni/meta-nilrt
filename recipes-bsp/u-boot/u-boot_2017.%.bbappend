SRC_URI = "git://git.natinst.com/u-boot.git;protocol=git;branch=dev/bmouring/n310-rev3/cardassia/2017.01"

SRCREV = "db7cb5d825be122612cd3b999365c8db2fd43091"

SPL_BINARY = "spl/boot.bin"
