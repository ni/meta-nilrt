# Needed at runtime by udisks2 (for fwupd); see udisks2_%.bbappend.
REQUIRED_DISTRO_FEATURES:remove = "polkit"
