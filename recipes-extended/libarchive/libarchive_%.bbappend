FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-archive_write_disk_-posix-windows-.c-Don-t-modify-at.patch \
"
