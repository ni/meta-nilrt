do_install:append() {
	chmod 4755 ${D}${bindir}/Xorg
}
