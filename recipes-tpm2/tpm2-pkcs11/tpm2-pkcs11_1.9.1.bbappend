FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-configure-ac-check-hardened-flags-with-extra-cflags.patch"
