FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-configure.ac-fix-hardening-flag-checks.patch"

