#FILESEXTRAPATHS_prepend := "${THISDIR}:${THISDIR}/${PN}:"

#SRC_URI = "file://${BPN}-${PV}.tar.bz2"

#SRC_URI[md5sum] = "8e727703343d4c18c73c79dd2009f8ed"
#SRC_URI[sha256sum] = "ea7e05b77ead159379392b3b275ca0c9cbacd7d936014e447cc7c5e27a767982"

