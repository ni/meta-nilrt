DEPENDS_remove += "docbook-utils-native"
