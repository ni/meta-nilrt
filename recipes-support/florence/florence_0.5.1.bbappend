FILESEXTRAPATHS_prepend := "${THISDIR}:${THISDIR}/files:${THISDIR}/:"

SRC_URI += "file://Remove-ability-to-close-keyboard.patch \
	    file://Change-layout-of-Florence-settings.patch \
	    file://Change-super-logo.patch \
	    file://Add-numpad-layout.patch"
