FILESEXTRAPATHS_prepend := "${THISDIR}:${THISDIR}/files:${THISDIR}/:"

SRC_URI += "\
	file://0001-Remove-ability-to-close-keyboard.patch \
	file://0002-Change-layout-of-Florence-settings.patch \
	file://0003-Change-super-logo.patch \
	file://0004-Add-numpad-layout.patch \
"
