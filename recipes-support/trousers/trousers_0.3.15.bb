S = "${WORKDIR}/${PN}-${PV}"

require trousers.inc

SRC_URI[md5sum] = "eb1b02e98c7d360749b9076196db3f0f"
SRC_URI[sha256sum] = "1e5be93e518372acf1d92d2f567d01a46fdb0b730487e544e6fb896c59cac77f"
