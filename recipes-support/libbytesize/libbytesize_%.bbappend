PACKAGECONFIG_remove += "python3"