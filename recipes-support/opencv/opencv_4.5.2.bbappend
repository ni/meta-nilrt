PACKAGECONFIG:remove = "gphoto2"
