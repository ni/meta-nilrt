FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-update-ca-certificates-use-t-with-mktemp.patch"

