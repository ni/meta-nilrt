RRECOMMENDS_${PN}_remove += "docker-registry"
