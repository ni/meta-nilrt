EXTRA_OECONF += "--disable-python"
