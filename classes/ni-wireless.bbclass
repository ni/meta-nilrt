
IMAGE_INSTALL += "iw libnl rfkill openssl wpa-supplicant wireless-regdb crda crdd ti-wifi-utils"

