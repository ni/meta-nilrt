DESCRIPTION = "Initramfs image intended to install the xfce-nilrt-image"
FACTORY_IMAGE = "xfce-nilrt-image"
IMAGE_DISPLAY_NAME = "minimal xfce runmode"

require restore-mode-image.inc
