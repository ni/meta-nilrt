# Start with the minimal bundle as a base
require minimal-nilrt-bundle.bb

BUNDLE_IMAGE = "lvcomms-nilrt-bundle-image"
