# Start with the minimal bundle image as a base
require minimal-nilrt-bundle-image.bb

BASEROOTFS_IMAGE = "lvcomms-nilrt-image"
