PACKAGECONFIG:remove += "uhd"