include nilrt_rauc.inc
