CVE_PRODUCT ?= "zlib:zlib"