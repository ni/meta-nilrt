CVE_PRODUCT ?= "lz4_project:lz4"