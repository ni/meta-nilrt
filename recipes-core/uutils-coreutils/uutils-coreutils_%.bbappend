PACKAGECONFIG:remove = "selinux"
