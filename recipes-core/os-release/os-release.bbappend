OS_RELEASE_FIELDS += "BUILD_ID"

BUILD_ID = "${BUILDNAME}"
