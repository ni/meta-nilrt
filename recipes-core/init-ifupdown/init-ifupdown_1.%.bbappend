FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
INITSCRIPT_PARAMS = "start 01 3 4 5 . stop 80 0 1 2 6 ."
