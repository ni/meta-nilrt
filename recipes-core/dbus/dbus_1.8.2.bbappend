INITSCRIPT_PARAMS = "start 02 5 3 2 . stop 37 0 1 6 ."