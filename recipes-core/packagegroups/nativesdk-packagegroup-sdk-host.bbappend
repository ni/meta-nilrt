RDEPENDS:${PN} += "nativesdk-squashfs-tools \
	       nativesdk-libarchive \
	       "
