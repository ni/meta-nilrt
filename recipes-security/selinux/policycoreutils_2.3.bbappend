FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://policycoreutils-semodule-Stack-size-limit-check-for-NILRT.patch \
"
