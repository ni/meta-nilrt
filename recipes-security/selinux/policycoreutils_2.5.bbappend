FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-semodule-Stack-size-limit-check-for-NILRT.patch \
"
