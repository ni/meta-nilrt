include refpolicy-ni.inc

SRC_URI =+ "file://refpolicy-fix-optional-issue-on-sysadm-module.patch \
            file://refpolicy-unconfined_u-default-user.patch \
           "
