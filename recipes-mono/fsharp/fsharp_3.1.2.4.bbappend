FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://0001-configure.ac-demote-gacdir-error-to-warn.patch \
"
