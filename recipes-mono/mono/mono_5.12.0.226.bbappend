#Overwrite any files from the meta-mono layer
FILESPATH_prepend := "${THISDIR}/files:"
