DEPENDS_append_class-target = " openldap"
