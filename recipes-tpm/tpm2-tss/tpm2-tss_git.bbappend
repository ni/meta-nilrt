DEFAULT_PREFERENCE = "1"
SRC_URI = "${NILRT_GIT}/tpm2-tss.git;protocol=git;branch=nilrt/18.0;name=${BPN};destsuffix=${BPN}"
