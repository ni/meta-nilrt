RDEPENDS_${PN} += "kernel-devsrc"
