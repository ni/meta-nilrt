FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Don-t-print-PID-uniquified-core-file-for-skipped-tes.patch \
           "
