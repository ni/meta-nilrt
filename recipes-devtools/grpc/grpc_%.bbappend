FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-deprecated-MutexLock-pointer-constructor.patch"

