SRC_URI = "${NILRT_GIT}/mkinitcpio.git;protocol=git;branch=nilrt/18.0"
SRCREV = "37df4fe219b5bdf8373d8a3c9c6145c122bb494b"
