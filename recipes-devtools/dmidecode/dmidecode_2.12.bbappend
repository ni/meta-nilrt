do_install_append() {
	chmod 6755 ${D}${sbindir}/dmidecode
}
