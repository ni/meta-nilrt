do_install:append() {
	chmod 6755 ${D}${sbindir}/dmidecode
}
