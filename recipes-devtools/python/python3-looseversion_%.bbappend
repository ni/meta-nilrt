# Provide native variant for python3-looseversion
# Needed by the Salt 3008.3 build. 
BBCLASSEXTEND += "native"
