DEBIAN_NOAUTONAME_lib${BPN}2 = "1"
