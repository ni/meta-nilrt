inherit setuptools3_legacy
require python-nose.inc
