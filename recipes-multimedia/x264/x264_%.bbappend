
inherit nilrt-permit-commercial

do_sanity_check_commercial() {
	# x264 is distributed under GPLv2 - which is fine.
	exit 0
}
